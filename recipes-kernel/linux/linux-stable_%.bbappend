FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_sun8i-s3-pinecube = " \
	file://sun8i-s3-pinecube-extra-config.cfg \
"
